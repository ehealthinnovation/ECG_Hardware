# IAR project ECG.ewp, settings and files
configuration CC2541DK-MINI Keyfob (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; CC2540_MINIDK
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\hal\include; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.3.2\Projects\ble\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE
  ICC8051.CCIncludePath2: C:\Texas Instruments\BLE-CC254x-1.3.2\Projects\ble\common; C:\Texas Instruments\BLE-CC254x-1.3.2\Projects\ble\include; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\hal\include; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\hal\target\CC2540EB; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\osal\include; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\services\saddr; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\ble\include; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\ble\controller\phy; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\ble\controller\include; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\ble\hci; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\ble\host; C:\Texas Instruments\BLE-CC254x-1.3.2\Projects\ble\common\cc2540; C:\Texas Instruments\BLE-CC254x-1.3.2\Projects\ble\common\npi\npi_np; C:\Texas Instruments\BLE-CC254x-1.3.2\Projects\ble\Profiles\Roles; C:\Texas Instruments\BLE-CC254x-1.3.2\Projects\ble\Profiles\SimpleProfile; C:\Texas Instruments\BLE-CC254x-1.3.2\Projects\ble\Profiles\DevInfo; ..\Profiles\DevInfo; ..\Profiles\ECGProfile; ..\Profiles\AccelProfile
configuration CC2541-OAD-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\hal\include; C:\Texas Instruments\BLE-CC254x-1.3.2\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541-OAD-ImgA\Exe\SimpleBLEPeripheral"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
configuration CC2541-OAD-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541-OAD-ImgB\Exe\SimpleBLEPeripheral"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration CC2541-OAD-Encrypted-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_SECURE; FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541-OAD-Encrypted-ImgA\Exe\SimpleBLEPeripheral"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgAe.xcl
configuration CC2541-OAD-Encrypted-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_SECURE; FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541-OAD-Encrypted-ImgB\Exe\SimpleBLEPeripheral"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgBe.xcl
  group APP
    ../Source/: ccdefines.h ECG.c ECG.h ECG_Main.c OSAL_ECG.c
  group APP/ADS1293
    ../Source/: TI_ADS1293.h TI_ADS1293_register_settings.h
  group APP/LIS3DH
    ../Source/: lis3dh.h
  group HAL/Common
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/ble/host/: linkdb.h
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/ble/controller/include/: ll.h phy.h
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Projects/ble/common/npi/npi_np/: npi.h
  group LIB
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Projects/ble/Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Projects/ble/Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Projects/ble/common/npi/npi_np/: npi.c
  group OSAL
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/ble/include/: bcomdef.h
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../Profiles/AccelProfile/: AccelProfile.c AccelProfile.h
    ../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../Profiles/ECGProfile/: ECGProfile.c ECGProfile.h
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Projects/ble/Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Projects/ble/Include/: gapgattserver.h gattservapp.h
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Components/ble/host/: gatt_uuid.c
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Projects/ble/Profiles/OAD/: oad.h oad_target.c oad_target.h
  group TOOLS
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Projects/ble/config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../../../../../Texas Instruments/BLE-CC254x-1.3.2/Projects/ble/common/cc2540/: OnBoard.c OnBoard.h
